# IAR project BSL.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430F513x_BSL_AREA.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: C:\Documents and Settings\Administrator\Desktop\Custom BSL Zip File\Released BSL Source\CC430F613x 00.05.04.52\CONFIG\lnk430F513x_BSL_AREA.xcl
  group (top)
    ./: BSL430_API.c BSL430_Command_Interpreter.c BSL430_Low_Level_Init.s43 BSL430_PI_USCIA.c
